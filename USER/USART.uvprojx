# Keil uVision project USART.uvprojx, settings and files
target USART (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE;..\HARDWARE\SPI;..\HARDWARE\OLED;..\HARDWARE\MYGUI;..\HARDWARE\esp8266-ap;..\HARDWARE\USART2;..\HARDWARE\MALLOC;..\HARDWARE\EXTI;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\HARDWARE\USART4;..\HARDWARE\Utils;..\HARDWARE\Gizwits;..\HARDWARE\DHT11;..\HARDWARE\GY30;..\HARDWARE\TftLcd;..\HARDWARE;..\HARDWARE\TftLcd
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/: myconf.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/: ws2812.c
    ../HARDWARE/SPI/: spi2.c
    ../HARDWARE/MYGUI/: myGUI.c
    ../HARDWARE/esp8266-ap/: esp8266-ap.c commonnn.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART4/: USART4.C
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/GY30/: bh1750.c
    ../HARDWARE/TftLcd/: GUI.c Lcd_Driver.c
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group giwit
    ../HARDWARE/Gizwits/: gizwits_product.c gizwits_protocol.c
    ../HARDWARE/Utils/: common.c dataPointTools.c ringbuffer.c
